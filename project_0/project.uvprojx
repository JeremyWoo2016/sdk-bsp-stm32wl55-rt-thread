# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WLE5JCIx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, STM32WL55xx, __RTTHREAD__
  c include: applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\libraries\STM32WLxx_HAL\STM32WLxx_HAL_Driver\Inc;..\libraries\STM32WLxx_HAL\CMSIS\Device\ST\stm32wlxx\Include;..\libraries\STM32WLxx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c waitqueue.c ringbuffer.c workqueue.c ringblk_buf.c
  group Drivers
    board/CubeMX_Config/Src/: stm32wlxx_hal_msp.c
    ../libraries/STM32WLxx_HAL/CMSIS/Device/ST/STM32WLxx/Source/Templates/arm/: startup_stm32wl55xx_cm4.s
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group finsh
    ../../../components/finsh/: msh.c finsh_node.c finsh_parser.c cmd.c finsh_vm.c shell.c finsh_var.c finsh_compiler.c finsh_heap.c finsh_ops.c finsh_error.c finsh_token.c finsh_init.c
  group Kernel
    ../../../src/: kservice.c clock.c irq.c components.c idle.c mem.c thread.c object.c device.c timer.c scheduler.c ipc.c mempool.c
  group STM32_HAL
    ../libraries/STM32WLxx_HAL/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_pwr.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_usart.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cryp.c stm32wlxx_hal_usart_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_cortex.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal.c stm32wlxx_hal_rcc.c stm32wlxx_hal_dma.c stm32wlxx_hal_uart.c stm32wlxx_hal_comp.c stm32wlxx_hal_rng.c stm32wlxx_hal_crc.c stm32wlxx_hal_crc_ex.c stm32wlxx_hal_cryp_ex.c
    ../libraries/STM32WLxx_HAL/CMSIS/Device/ST/STM32WLxx/Source/Templates/: system_stm32wlxx.c
